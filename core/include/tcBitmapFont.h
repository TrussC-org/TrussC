#pragma once

#include <cstdint>
#include <cstring>
#include <vector>
#include <array>
#include <algorithm>

// =============================================================================
// TrussC Bitmap Font
// =============================================================================
// ASCII (0x20-0x7E) is built in via the freeglut/X11 8x13 font below.
// Everything else is opt-in via registerGlyph(), letting addons (or your own
// app code) plug in additional codepoints — kana, Hangul, custom logos,
// animated frames, anything.
//
// Atlas layout (single 512x512 RGBA texture, allocated lazily):
//
//   cell 0..94  : ASCII printable (halfwidth)
//   cell 95     : Missing-glyph "tofu" □ shown for unknown codepoints
//   cell 96..   : Registered ranges, in registration order
//
// Each cell is 8x16 pixels (13-pixel glyph + 3-pixel padding). A halfwidth
// glyph occupies 1 cell, a fullwidth glyph occupies 2 consecutive cells.
//
// Public API:
//   - Width, Glyph, registerGlyph, registerGlyphs, updateGlyph
//   - compile8x13 / compile16x13 (compile-time ASCII-art -> packed bytes)
//   - lookupGlyph, codepointPixelWidth, utf8Decode (used by renderer)
// =============================================================================

namespace trussc {
namespace bitmapfont {

// -----------------------------------------------------------------------------
// Constants
// -----------------------------------------------------------------------------

constexpr int CHAR_HEIGHT       = 13;
constexpr int GLYPH_WIDTH_HALF  = 8;
constexpr int GLYPH_WIDTH_FULL  = 16;
constexpr int GLYPH_WIDTH       = GLYPH_WIDTH_HALF;  // legacy name

constexpr int CELL_W            = 8;
constexpr int CELL_H            = 16;   // 13 px glyph + 3 px padding

constexpr int ATLAS_WIDTH       = 512;
constexpr int ATLAS_HEIGHT      = 512;
constexpr int CELLS_PER_ROW     = ATLAS_WIDTH / CELL_W;   // 64
constexpr int CELLS_PER_COL     = ATLAS_HEIGHT / CELL_H;  // 32
constexpr int TOTAL_CELLS       = CELLS_PER_ROW * CELLS_PER_COL;

// Legacy names kept for code that pre-dates the cell-based design
constexpr int CHAR_TEX_WIDTH    = CELL_W;
constexpr int CHAR_TEX_HEIGHT   = CELL_H;
constexpr int CHARS_PER_ROW     = CELLS_PER_ROW;

constexpr float TEX_CELL_W      = (float)CELL_W  / ATLAS_WIDTH;
constexpr float TEX_CELL_H      = (float)CELL_H  / ATLAS_HEIGHT;  // fallback only
constexpr float TEX_CHAR_WIDTH  = TEX_CELL_W;
constexpr float TEX_CHAR_HEIGHT = TEX_CELL_H;

// Reserved cell shown for any codepoint not in ASCII and not registered.
constexpr int TOFU_CELL              = 95;
constexpr int FIRST_REGISTERED_CELL  = 96;

// -----------------------------------------------------------------------------
// Public types
// -----------------------------------------------------------------------------

enum class Width : uint8_t {
    Halfwidth = 1,   // 8x13 px, 13 bytes per glyph (1 byte per row, MSB first)
    Fullwidth = 2    // 16x13 px, 26 bytes per glyph (2 bytes per row: left, right; MSB first)
};

// One glyph the user wants the framework to know about.
struct Glyph {
    uint32_t       codepoint;
    const uint8_t* data;       // must outlive every drawBitmapString call
    Width          width;
};

// Result of lookupGlyph(): where in the atlas a codepoint lives.
struct GlyphCell {
    uint16_t atlasCellX;
    uint16_t atlasCellY;
    uint8_t  cellWidth;   // 1 = halfwidth, 2 = fullwidth
};

// -----------------------------------------------------------------------------
// Internal registry storage
// -----------------------------------------------------------------------------
namespace internal {
    struct StoredGlyph {
        uint32_t       cp;
        uint16_t       cellStart;
        const uint8_t* data;
        uint8_t        width;  // 1 or 2
    };
    // Sorted by `cp` for binary-search lookup.
    inline std::vector<StoredGlyph> registry;

    // Next free atlas cell for newly registered glyphs.
    inline uint16_t nextFreeCell = FIRST_REGISTERED_CELL;

    // Monotonically incremented every time the registry changes. The runtime
    // (TrussC.h ensureFontAtlas) compares against `builtAtlasVersion` to
    // decide when to re-upload the atlas texture.
    inline uint64_t registryVersion = 0;
}

// -----------------------------------------------------------------------------
// UTF-8 decoding
// -----------------------------------------------------------------------------
// Decodes one codepoint from the byte stream at *p, advances *p past it.
// On error, advances 1 byte and returns 0xFFFD (replacement).
inline uint32_t utf8Decode(const char*& p, const char* end) {
    if (p >= end) return 0;
    unsigned char c0 = (unsigned char)*p;
    if (c0 == 0) return 0;
    if (c0 < 0x80) { ++p; return c0; }
    int extra;
    uint32_t cp;
    if      ((c0 & 0xE0) == 0xC0) { extra = 1; cp = c0 & 0x1F; }
    else if ((c0 & 0xF0) == 0xE0) { extra = 2; cp = c0 & 0x0F; }
    else if ((c0 & 0xF8) == 0xF0) { extra = 3; cp = c0 & 0x07; }
    else { ++p; return 0xFFFD; }
    if (p + 1 + extra > end) { p = end; return 0xFFFD; }
    ++p;
    for (int i = 0; i < extra; ++i) {
        unsigned char c = (unsigned char)*p;
        if ((c & 0xC0) != 0x80) { return 0xFFFD; }
        cp = (cp << 6) | (c & 0x3F);
        ++p;
    }
    return cp;
}

// -----------------------------------------------------------------------------
// Registry queries
// -----------------------------------------------------------------------------
inline const internal::StoredGlyph* findRegistered(uint32_t cp) {
    auto& reg = internal::registry;
    auto it = std::lower_bound(reg.begin(), reg.end(), cp,
        [](const internal::StoredGlyph& a, uint32_t b){ return a.cp < b; });
    if (it != reg.end() && it->cp == cp) return &*it;
    return nullptr;
}

// Codepoint -> atlas cell coordinates. Falls back to TOFU when unknown.
inline GlyphCell lookupGlyph(uint32_t cp) {
    if (cp >= 0x20 && cp <= 0x7E) {
        uint16_t idx = (uint16_t)(cp - 0x20);
        return GlyphCell{
            (uint16_t)(idx % CELLS_PER_ROW),
            (uint16_t)(idx / CELLS_PER_ROW),
            1
        };
    }
    if (const auto* g = findRegistered(cp)) {
        return GlyphCell{
            (uint16_t)(g->cellStart % CELLS_PER_ROW),
            (uint16_t)(g->cellStart / CELLS_PER_ROW),
            g->width
        };
    }
    return GlyphCell{
        (uint16_t)(TOFU_CELL % CELLS_PER_ROW),
        (uint16_t)(TOFU_CELL / CELLS_PER_ROW),
        1
    };
}

inline int glyphPixelWidth(const GlyphCell& g) { return g.cellWidth * CELL_W; }

inline int codepointPixelWidth(uint32_t cp) {
    if (cp >= 0x20 && cp <= 0x7E) return CELL_W;
    if (const auto* g = findRegistered(cp)) return g->width * CELL_W;
    return CELL_W;  // tofu is halfwidth
}

// -----------------------------------------------------------------------------
// Tier helpers (atlas grows row-by-row on demand)
// -----------------------------------------------------------------------------
inline int codepointRequiredRows(uint32_t cp) {
    if (cp >= 0x20 && cp <= 0x7E) return 2;       // ASCII + TOFU live in rows 0-1
    if (const auto* g = findRegistered(cp)) {
        uint16_t lastCell = (uint16_t)(g->cellStart + g->width - 1);
        return (lastCell / CELLS_PER_ROW) + 1;
    }
    return 2;  // tofu fallback
}

inline int textRequiredRows(const char* p, const char* end) {
    int maxRows = 0;
    while (p < end) {
        unsigned char b0 = (unsigned char)*p;
        if (b0 == '\n' || b0 == '\t' || b0 < 32) { ++p; continue; }
        uint32_t cp = utf8Decode(p, end);
        if (cp == 0) break;
        int r = codepointRequiredRows(cp);
        if (r > maxRows) maxRows = r;
    }
    return maxRows;
}

// UV lookup. Caller passes the current atlas height in cell rows so V can be
// normalized correctly (atlas grows lazily, so the v denominator varies).
inline void getCodepointTexCoord(uint32_t cp, int atlasRows,
                                 float& u, float& v, float& u2, float& v2) {
    GlyphCell g = lookupGlyph(cp);
    float texCellH = (atlasRows > 0) ? (1.0f / (float)atlasRows) : TEX_CELL_H;
    u  = g.atlasCellX * TEX_CELL_W;
    v  = g.atlasCellY * texCellH;
    u2 = u + g.cellWidth * TEX_CELL_W;
    v2 = v + texCellH;
}

// -----------------------------------------------------------------------------
// Compile-time ASCII-art -> packed bytes
//
// Each row uses '#' for an on pixel, anything else for off. The 13 input
// strings must each be at least GLYPH_WIDTH (8 or 16) chars long; characters
// past that are ignored, shorter strings are zero-padded.
// -----------------------------------------------------------------------------
constexpr std::array<uint8_t, 13> compile8x13(const char* const (&rows)[13]) {
    std::array<uint8_t, 13> out{};
    for (int r = 0; r < 13; ++r) {
        uint8_t b = 0;
        for (int c = 0; c < 8; ++c) {
            if (rows[r][c] == '\0') break;
            if (rows[r][c] == '#') b |= (uint8_t)(0x80 >> c);
        }
        out[r] = b;
    }
    return out;
}

constexpr std::array<uint8_t, 26> compile16x13(const char* const (&rows)[13]) {
    std::array<uint8_t, 26> out{};
    for (int r = 0; r < 13; ++r) {
        uint8_t lo = 0, hi = 0;
        for (int c = 0; c < 8; ++c) {
            if (rows[r][c] == '\0') break;
            if (rows[r][c] == '#') lo |= (uint8_t)(0x80 >> c);
        }
        for (int c = 0; c < 8; ++c) {
            if (rows[r][8 + c] == '\0') break;
            if (rows[r][8 + c] == '#') hi |= (uint8_t)(0x80 >> c);
        }
        out[r * 2 + 0] = lo;
        out[r * 2 + 1] = hi;
    }
    return out;
}

// -----------------------------------------------------------------------------
// Registration API
// -----------------------------------------------------------------------------

// Register one glyph. Replaces any previously registered glyph at the same
// codepoint. The atlas is marked dirty and will be re-uploaded on the next
// drawBitmapString call.
inline void registerGlyph(const Glyph& g) {
    using internal::StoredGlyph;
    auto& reg = internal::registry;

    uint8_t w = (uint8_t)g.width;

    auto it = std::lower_bound(reg.begin(), reg.end(), g.codepoint,
        [](const StoredGlyph& a, uint32_t b){ return a.cp < b; });
    if (it != reg.end() && it->cp == g.codepoint) {
        // Replace in place — keep the existing cell position so the atlas
        // doesn't have to relocate other glyphs.
        if (it->width == w) {
            it->data = g.data;
        } else {
            // Width change: drop the old cell range; new cells allocated below.
            // (Cells of replaced glyphs are leaked for simplicity; this only
            // matters if users re-register a lot with different widths, which
            // is rare.)
            reg.erase(it);
            it = reg.end();  // re-search below
        }
        if (it != reg.end() && it->cp == g.codepoint) {
            ++internal::registryVersion;
            return;
        }
    }

    // Allocate fresh cells. Fullwidth glyphs must start on an even cell so
    // their 2 cells don't straddle a row boundary.
    if (w == 2 && (internal::nextFreeCell % 2 != 0)) ++internal::nextFreeCell;
    StoredGlyph sg{ g.codepoint, internal::nextFreeCell, g.data, w };
    internal::nextFreeCell = (uint16_t)(internal::nextFreeCell + w);

    it = std::lower_bound(reg.begin(), reg.end(), g.codepoint,
        [](const StoredGlyph& a, uint32_t b){ return a.cp < b; });
    reg.insert(it, sg);
    ++internal::registryVersion;
}

// Register a batch of glyphs.
template <size_t N>
inline void registerGlyphs(const Glyph (&glyphs)[N]) {
    for (const auto& g : glyphs) registerGlyph(g);
}

// Update an existing registered glyph's pixel data without changing its atlas
// position. Useful for animation — keep the same codepoint registered, swap
// `data` each frame.
inline void updateGlyph(uint32_t cp, const uint8_t* newData) {
    if (auto* g = const_cast<internal::StoredGlyph*>(findRegistered(cp))) {
        g->data = newData;
        ++internal::registryVersion;
    }
}

// -----------------------------------------------------------------------------
// ASCII glyph data (freeglut/X11 8x13 fixed-width)
// -----------------------------------------------------------------------------
inline const uint8_t* asciiGlyph(uint32_t cp) {
    static const uint8_t ASCII[95][13] = {
        {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // ' '
        {0x00,0x00,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x00,0x18,0x18,0x00}, // '!'
        {0x00,0x00,0x66,0x66,0x66,0x24,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '"'
        {0x00,0x00,0x00,0x36,0x36,0x7F,0x36,0x36,0x7F,0x36,0x36,0x00,0x00}, // '#'
        {0x00,0x08,0x1E,0x28,0x28,0x1C,0x0A,0x0A,0x3C,0x08,0x08,0x00,0x00}, // '$'
        {0x00,0x00,0x32,0x32,0x04,0x08,0x08,0x10,0x10,0x26,0x26,0x00,0x00}, // '%'
        {0x00,0x00,0x1C,0x22,0x22,0x14,0x18,0x29,0x45,0x42,0x3D,0x00,0x00}, // '&'
        {0x00,0x00,0x18,0x18,0x18,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '\''
        {0x00,0x00,0x04,0x08,0x10,0x10,0x10,0x10,0x10,0x08,0x04,0x00,0x00}, // '('
        {0x00,0x00,0x20,0x10,0x08,0x08,0x08,0x08,0x08,0x10,0x20,0x00,0x00}, // ')'
        {0x00,0x00,0x00,0x00,0x24,0x18,0x7E,0x18,0x24,0x00,0x00,0x00,0x00}, // '*'
        {0x00,0x00,0x00,0x00,0x08,0x08,0x3E,0x08,0x08,0x00,0x00,0x00,0x00}, // '+'
        {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x10,0x00}, // ','
        {0x00,0x00,0x00,0x00,0x00,0x00,0x3E,0x00,0x00,0x00,0x00,0x00,0x00}, // '-'
        {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x00,0x00}, // '.'
        {0x00,0x00,0x02,0x02,0x04,0x08,0x08,0x10,0x20,0x40,0x40,0x00,0x00}, // '/'
        {0x00,0x00,0x1C,0x22,0x22,0x26,0x2A,0x32,0x22,0x22,0x1C,0x00,0x00}, // '0'
        {0x00,0x00,0x08,0x18,0x28,0x08,0x08,0x08,0x08,0x08,0x3E,0x00,0x00}, // '1'
        {0x00,0x00,0x1C,0x22,0x02,0x04,0x08,0x10,0x20,0x22,0x3E,0x00,0x00}, // '2'
        {0x00,0x00,0x1C,0x22,0x02,0x02,0x0C,0x02,0x02,0x22,0x1C,0x00,0x00}, // '3'
        {0x00,0x00,0x04,0x0C,0x14,0x24,0x44,0x7E,0x04,0x04,0x04,0x00,0x00}, // '4'
        {0x00,0x00,0x3E,0x20,0x20,0x3C,0x02,0x02,0x02,0x22,0x1C,0x00,0x00}, // '5'
        {0x00,0x00,0x0C,0x10,0x20,0x3C,0x22,0x22,0x22,0x22,0x1C,0x00,0x00}, // '6'
        {0x00,0x00,0x3E,0x22,0x02,0x04,0x04,0x08,0x08,0x08,0x08,0x00,0x00}, // '7'
        {0x00,0x00,0x1C,0x22,0x22,0x22,0x1C,0x22,0x22,0x22,0x1C,0x00,0x00}, // '8'
        {0x00,0x00,0x1C,0x22,0x22,0x22,0x1E,0x02,0x02,0x04,0x18,0x00,0x00}, // '9'
        {0x00,0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x18,0x18,0x00,0x00}, // ':'
        {0x00,0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x18,0x18,0x10,0x00}, // ';'
        {0x00,0x00,0x02,0x04,0x08,0x10,0x20,0x10,0x08,0x04,0x02,0x00,0x00}, // '<'
        {0x00,0x00,0x00,0x00,0x00,0x3E,0x00,0x3E,0x00,0x00,0x00,0x00,0x00}, // '='
        {0x00,0x00,0x20,0x10,0x08,0x04,0x02,0x04,0x08,0x10,0x20,0x00,0x00}, // '>'
        {0x00,0x00,0x1C,0x22,0x02,0x04,0x08,0x08,0x08,0x00,0x08,0x08,0x00}, // '?'
        {0x00,0x00,0x1C,0x22,0x4A,0x56,0x56,0x4C,0x20,0x1E,0x00,0x00,0x00}, // '@'
        {0x00,0x00,0x08,0x14,0x22,0x22,0x22,0x3E,0x22,0x22,0x22,0x00,0x00}, // 'A'
        {0x00,0x00,0x3C,0x22,0x22,0x22,0x3C,0x22,0x22,0x22,0x3C,0x00,0x00}, // 'B'
        {0x00,0x00,0x1C,0x22,0x40,0x40,0x40,0x40,0x40,0x22,0x1C,0x00,0x00}, // 'C'
        {0x00,0x00,0x38,0x24,0x22,0x22,0x22,0x22,0x22,0x24,0x38,0x00,0x00}, // 'D'
        {0x00,0x00,0x3E,0x20,0x20,0x20,0x3C,0x20,0x20,0x20,0x3E,0x00,0x00}, // 'E'
        {0x00,0x00,0x3E,0x20,0x20,0x20,0x3C,0x20,0x20,0x20,0x20,0x00,0x00}, // 'F'
        {0x00,0x00,0x1C,0x22,0x40,0x40,0x4E,0x42,0x42,0x22,0x1C,0x00,0x00}, // 'G'
        {0x00,0x00,0x22,0x22,0x22,0x22,0x3E,0x22,0x22,0x22,0x22,0x00,0x00}, // 'H'
        {0x00,0x00,0x3E,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x3E,0x00,0x00}, // 'I'
        {0x00,0x00,0x0E,0x04,0x04,0x04,0x04,0x04,0x44,0x44,0x38,0x00,0x00}, // 'J'
        {0x00,0x00,0x22,0x24,0x28,0x30,0x30,0x28,0x24,0x22,0x22,0x00,0x00}, // 'K'
        {0x00,0x00,0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x3E,0x00,0x00}, // 'L'
        {0x00,0x00,0x41,0x63,0x55,0x49,0x41,0x41,0x41,0x41,0x41,0x00,0x00}, // 'M'
        {0x00,0x00,0x22,0x32,0x32,0x2A,0x2A,0x26,0x26,0x22,0x22,0x00,0x00}, // 'N'
        {0x00,0x00,0x1C,0x22,0x41,0x41,0x41,0x41,0x41,0x22,0x1C,0x00,0x00}, // 'O'
        {0x00,0x00,0x3C,0x22,0x22,0x22,0x3C,0x20,0x20,0x20,0x20,0x00,0x00}, // 'P'
        {0x00,0x00,0x1C,0x22,0x41,0x41,0x41,0x41,0x49,0x26,0x1D,0x00,0x00}, // 'Q'
        {0x00,0x00,0x3C,0x22,0x22,0x22,0x3C,0x28,0x24,0x22,0x22,0x00,0x00}, // 'R'
        {0x00,0x00,0x1C,0x22,0x20,0x10,0x08,0x04,0x02,0x22,0x1C,0x00,0x00}, // 'S'
        {0x00,0x00,0x7F,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x00,0x00}, // 'T'
        {0x00,0x00,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x1C,0x00,0x00}, // 'U'
        {0x00,0x00,0x41,0x41,0x41,0x22,0x22,0x14,0x14,0x08,0x08,0x00,0x00}, // 'V'
        {0x00,0x00,0x41,0x41,0x41,0x41,0x49,0x49,0x55,0x63,0x41,0x00,0x00}, // 'W'
        {0x00,0x00,0x41,0x22,0x14,0x08,0x08,0x14,0x22,0x41,0x41,0x00,0x00}, // 'X'
        {0x00,0x00,0x41,0x22,0x14,0x08,0x08,0x08,0x08,0x08,0x08,0x00,0x00}, // 'Y'
        {0x00,0x00,0x7F,0x02,0x04,0x08,0x08,0x10,0x20,0x40,0x7F,0x00,0x00}, // 'Z'
        {0x00,0x00,0x1E,0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x1E,0x00,0x00}, // '['
        {0x00,0x00,0x40,0x40,0x20,0x10,0x08,0x08,0x04,0x02,0x02,0x00,0x00}, // '\\'
        {0x00,0x00,0x3C,0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x3C,0x00,0x00}, // ']'
        {0x00,0x08,0x14,0x22,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '^'
        {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x7F,0x00,0x00}, // '_'
        {0x00,0x18,0x18,0x08,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '`'
        {0x00,0x00,0x00,0x00,0x00,0x1C,0x02,0x1E,0x22,0x22,0x1E,0x00,0x00}, // 'a'
        {0x00,0x00,0x20,0x20,0x20,0x3C,0x22,0x22,0x22,0x22,0x3C,0x00,0x00}, // 'b'
        {0x00,0x00,0x00,0x00,0x00,0x1C,0x22,0x20,0x20,0x22,0x1C,0x00,0x00}, // 'c'
        {0x00,0x00,0x02,0x02,0x02,0x1E,0x22,0x22,0x22,0x22,0x1E,0x00,0x00}, // 'd'
        {0x00,0x00,0x00,0x00,0x00,0x1C,0x22,0x3E,0x20,0x22,0x1C,0x00,0x00}, // 'e'
        {0x00,0x00,0x0C,0x12,0x10,0x10,0x3C,0x10,0x10,0x10,0x10,0x00,0x00}, // 'f'
        {0x00,0x00,0x00,0x00,0x00,0x1E,0x22,0x22,0x22,0x1E,0x02,0x22,0x1C}, // 'g'
        {0x00,0x00,0x20,0x20,0x20,0x2C,0x32,0x22,0x22,0x22,0x22,0x00,0x00}, // 'h'
        {0x00,0x00,0x08,0x08,0x00,0x18,0x08,0x08,0x08,0x08,0x1C,0x00,0x00}, // 'i'
        {0x00,0x00,0x04,0x04,0x00,0x0C,0x04,0x04,0x04,0x04,0x44,0x44,0x38}, // 'j'
        {0x00,0x00,0x20,0x20,0x20,0x24,0x28,0x30,0x28,0x24,0x22,0x00,0x00}, // 'k'
        {0x00,0x00,0x18,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x1C,0x00,0x00}, // 'l'
        {0x00,0x00,0x00,0x00,0x00,0x76,0x49,0x49,0x49,0x49,0x49,0x00,0x00}, // 'm'
        {0x00,0x00,0x00,0x00,0x00,0x2C,0x32,0x22,0x22,0x22,0x22,0x00,0x00}, // 'n'
        {0x00,0x00,0x00,0x00,0x00,0x1C,0x22,0x22,0x22,0x22,0x1C,0x00,0x00}, // 'o'
        {0x00,0x00,0x00,0x00,0x00,0x3C,0x22,0x22,0x22,0x3C,0x20,0x20,0x20}, // 'p'
        {0x00,0x00,0x00,0x00,0x00,0x1E,0x22,0x22,0x22,0x1E,0x02,0x02,0x02}, // 'q'
        {0x00,0x00,0x00,0x00,0x00,0x2C,0x32,0x20,0x20,0x20,0x20,0x00,0x00}, // 'r'
        {0x00,0x00,0x00,0x00,0x00,0x1E,0x20,0x1C,0x02,0x02,0x3C,0x00,0x00}, // 's'
        {0x00,0x00,0x00,0x10,0x10,0x3C,0x10,0x10,0x10,0x12,0x0C,0x00,0x00}, // 't'
        {0x00,0x00,0x00,0x00,0x00,0x22,0x22,0x22,0x22,0x26,0x1A,0x00,0x00}, // 'u'
        {0x00,0x00,0x00,0x00,0x00,0x22,0x22,0x22,0x14,0x14,0x08,0x00,0x00}, // 'v'
        {0x00,0x00,0x00,0x00,0x00,0x41,0x49,0x49,0x49,0x55,0x22,0x00,0x00}, // 'w'
        {0x00,0x00,0x00,0x00,0x00,0x22,0x14,0x08,0x08,0x14,0x22,0x00,0x00}, // 'x'
        {0x00,0x00,0x00,0x00,0x00,0x22,0x22,0x22,0x22,0x1E,0x02,0x22,0x1C}, // 'y'
        {0x00,0x00,0x00,0x00,0x00,0x3E,0x04,0x08,0x10,0x20,0x3E,0x00,0x00}, // 'z'
        {0x00,0x00,0x06,0x08,0x08,0x08,0x30,0x08,0x08,0x08,0x06,0x00,0x00}, // '{'
        {0x00,0x00,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x00,0x00}, // '|'
        {0x00,0x00,0x30,0x08,0x08,0x08,0x06,0x08,0x08,0x08,0x30,0x00,0x00}, // '}'
        {0x00,0x00,0x31,0x49,0x46,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '~'
    };
    if (cp < 0x20 || cp > 0x7E) return ASCII[0];
    return ASCII[cp - 0x20];
}

// -----------------------------------------------------------------------------
// Atlas rasterization helpers (internal)
// -----------------------------------------------------------------------------
namespace internal {

inline void writePixel(uint8_t* pixels, int atlasH, int x, int y) {
    if (x < 0 || x >= ATLAS_WIDTH || y < 0 || y >= atlasH) return;
    int idx = (y * ATLAS_WIDTH + x) * 4;
    pixels[idx + 0] = 255;
    pixels[idx + 1] = 255;
    pixels[idx + 2] = 255;
    pixels[idx + 3] = 255;
}

inline void rasterAscii(uint8_t* pixels, int atlasH, uint32_t cp, int baseX, int baseY) {
    const uint8_t* bits = asciiGlyph(cp);
    for (int row = 0; row < CHAR_HEIGHT; ++row) {
        uint8_t r = bits[row];
        for (int col = 0; col < GLYPH_WIDTH_HALF; ++col) {
            if (r & (0x80 >> col)) writePixel(pixels, atlasH, baseX + col, baseY + row + 1);
        }
    }
}

inline void rasterPackedHalf(uint8_t* pixels, int atlasH,
                             const uint8_t* bits, int baseX, int baseY) {
    for (int row = 0; row < CHAR_HEIGHT; ++row) {
        uint8_t r = bits[row];
        for (int col = 0; col < GLYPH_WIDTH_HALF; ++col) {
            if (r & (0x80 >> col)) writePixel(pixels, atlasH, baseX + col, baseY + row + 1);
        }
    }
}

inline void rasterPackedFull(uint8_t* pixels, int atlasH,
                             const uint8_t* bits, int baseX, int baseY) {
    for (int row = 0; row < CHAR_HEIGHT; ++row) {
        uint8_t lo = bits[row * 2 + 0];
        uint8_t hi = bits[row * 2 + 1];
        for (int col = 0; col < 8; ++col) {
            if (lo & (0x80 >> col)) writePixel(pixels, atlasH, baseX + col,     baseY + row + 1);
            if (hi & (0x80 >> col)) writePixel(pixels, atlasH, baseX + 8 + col, baseY + row + 1);
        }
    }
}

inline void rasterTofu(uint8_t* pixels, int atlasH, int baseX, int baseY) {
    const int W = CELL_W, H = CELL_H;
    for (int x = 1; x < W - 1; ++x) {
        writePixel(pixels, atlasH, baseX + x, baseY + 2);
        writePixel(pixels, atlasH, baseX + x, baseY + H - 3);
    }
    for (int y = 2; y < H - 2; ++y) {
        writePixel(pixels, atlasH, baseX + 1,     baseY + y);
        writePixel(pixels, atlasH, baseX + W - 2, baseY + y);
    }
}

}  // namespace internal

// -----------------------------------------------------------------------------
// Atlas generation
// -----------------------------------------------------------------------------
// Generate a 512 x (rows * CELL_H) RGBA atlas. Glyphs whose cells fall past
// the requested row count are skipped silently (tier-based growth).
// Caller owns the returned buffer (delete[]).
inline unsigned char* generateAtlasPixels(int rows) {
    if (rows <= 0) return nullptr;
    if (rows > CELLS_PER_COL) rows = CELLS_PER_COL;
    const int height = rows * CELL_H;
    const int totalBytes = ATLAS_WIDTH * height * 4;
    auto* pixels = new unsigned char[totalBytes];
    for (int i = 0; i < totalBytes; i += 4) {
        pixels[i + 0] = 255;
        pixels[i + 1] = 255;
        pixels[i + 2] = 255;
        pixels[i + 3] = 0;
    }

    // ASCII (cells 0..94, rows 0..1)
    for (uint32_t cp = 0x20; cp <= 0x7E; ++cp) {
        uint16_t cellIdx = (uint16_t)(cp - 0x20);
        int cy = (cellIdx / CELLS_PER_ROW) * CELL_H;
        if (cy + CELL_H > height) continue;
        int cx = (cellIdx % CELLS_PER_ROW) * CELL_W;
        internal::rasterAscii(pixels, height, cp, cx, cy);
    }

    // Tofu (cell 95)
    {
        int tcx = (TOFU_CELL % CELLS_PER_ROW) * CELL_W;
        int tcy = (TOFU_CELL / CELLS_PER_ROW) * CELL_H;
        if (tcy + CELL_H <= height) internal::rasterTofu(pixels, height, tcx, tcy);
    }

    // Registered glyphs
    for (const auto& sg : internal::registry) {
        int cy = (sg.cellStart / CELLS_PER_ROW) * CELL_H;
        if (cy + CELL_H > height) continue;
        int cx = (sg.cellStart % CELLS_PER_ROW) * CELL_W;
        if (sg.width == 1) internal::rasterPackedHalf(pixels, height, sg.data, cx, cy);
        else               internal::rasterPackedFull(pixels, height, sg.data, cx, cy);
    }
    return pixels;
}

// Legacy overload: full-height atlas (still useful as a one-shot dump).
inline unsigned char* generateAtlasPixels() {
    return generateAtlasPixels(CELLS_PER_COL);
}

// -----------------------------------------------------------------------------
// Legacy helpers (kept so older code paths compile)
// -----------------------------------------------------------------------------
inline const unsigned char* getCharBitmap(char c) {
    return asciiGlyph((unsigned char)c);
}

inline void getCharTexCoord(char c, float& u, float& v) {
    GlyphCell g = lookupGlyph((unsigned char)c);
    u = g.atlasCellX * TEX_CELL_W;
    v = g.atlasCellY * TEX_CELL_H;
}

}  // namespace bitmapfont
}  // namespace trussc
